# Keil uVision project STM32F4_DEMO.uvproj, settings and files
target STM32F407-FLASH (ARM-ADS)
  device: STM32F407IE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: DEMO +hex
  c flags: Optim=3 OneElfS=1
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\Include;..\CMSIS\STM32F4xx\Include;..\FatFS;..\FWLib\inc;..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../CMSIS/STM32F4xx/Source/: startup_stm32f4xx.s
  group CMSIS
    ../CMSIS/STM32F4xx/Source/: system_stm32f4xx.c
  group FWLib
    ../FWLib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
  group User
    ../User/: main.c stm32f4xx_it.c
  group DOC
    ../: README.TXT
